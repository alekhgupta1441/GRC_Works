options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: Chirp_Gui
    output_language: python
    title: Chirp Function
  states: {}

blocks:
- name: chirpLen_s
  id: variable
  parameters:
    value: '1'
  states: {}
- name: numSamples
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: start_Hz
  id: variable
  parameters:
    value: '100'
  states: {}
- name: stop_Hz
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
    vlen: numSamples
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: chirp.chirp(numSamples, chirpLen_s, start_Hz, stop_Hz)
    vlen: numSamples
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: numSamples
    type: float
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import chirp
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Chirp"'
    showports: 'True'
    type: float
    update_time: '0.1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-200'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: numSamples
    interp: samp_rate
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
