options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: awgn
    output_language: python
    title: AWGN
  states: {}

blocks:
- name: bandwidth_Hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:0,1,1,1
    label: Bandwidth (Hz)
    type: real
    value: '5000'
  states: {}
- name: centerFreq_Hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:0,0,1,1
    label: Center Frequency (Hz)
    type: real
    value: '7500'
  states: {}
- name: numSamples
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:0,3,1,1
    label: Number of Points
    type: int
    value: '1000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sampleRate_Hz
  states: {}
- name: sampleRate_Hz
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@0:0,2,1,1
    label: Sample Rate (Hz)
    type: int
    value: '30000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: numSamples
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: createNoise.createNoise(centerFreq_Hz, bandwidth_Hz, sampleRate_Hz, numSamples)
    vlen: numSamples
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: numSamples
    type: complex
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import createNoise
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@0:1,0,1,4
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-75'
    ymin: '-225'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: AWGN
    num_tabs: '1'
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
